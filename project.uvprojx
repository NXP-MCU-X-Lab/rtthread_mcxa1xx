# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxa153 (6230000::V6.23::ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.19.0.0
  cpu: IRAM(0x20000000,0x6000) IRAM2(0x04000000,0x2000) IROM(0x03000000,0x2000) IROM2(0x00000000,0x020000) XRAM(0x04002000,0x1000) CPUTYPE("Cortex-M33") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=3
  c define: __RTTHREAD__, CPU_MCXA153VLH, RT_USING_LIBC, RT_USING_ARMLIBC, DEBUG, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --target=arm-arm-none-eabi
  c include: rt-thread\components\libc\posix\io\eventfd;rt-thread\components\drivers\include;packages\nxp-mcx-series-latest\MCXA153;packages\nxp-mcx-cmsis-latest\Core\Include;rt-thread\components\drivers\include;packages\nxp-mcx-series-latest\MCXA153\components\codec;packages\nxp-mcx-series-latest\MCXA153\middleware\sdmmc\port;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\include;rt-thread\components\libc\posix\io\epoll;rt-thread\libcpu\arm\cortex-m33;rt-thread\components\utilities\ulog;Libraries\drivers\config;board\MCUX_Config\board;Libraries\drivers;rt-thread\components\drivers\phy;rt-thread\components\drivers\include;packages\nxp-mcx-series-latest\CMSIS\Core\Include;packages\nxp-mcx-series-latest\MCXA153\middleware\sdmmc\inc;rt-thread\libcpu\arm\common;board;rt-thread\components\drivers\include;rt-thread\components\drivers\smp_call;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\compilers\common\include;applications;rt-thread\components\finsh;.;packages\nxp-mcx-series-latest\MCXA153\drivers;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\extension
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x0 size 0x20000
  memory RVCT6: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x4000000 size 0x2000
  scatter file: .\board\linker_scripts\MCXA153_flash.scf
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    Libraries/drivers/: drv_pin.c drv_uart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c cmd.c msh_parse.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    rt-thread/src/klibc/: rt_vsscanf.c rt_vsnprintf_std.c kstring.c kerrno.c kstdio.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    packages/nxp-mcx-series-latest/MCXA153/arm/: startup_MCXA153.s
    packages/nxp-mcx-series-latest/MCXA153/drivers/: fsl_aoi.c fsl_clock.c fsl_cmc.c fsl_common.c fsl_common_arm.c fsl_crc.c fsl_ctimer.c fsl_edma.c fsl_edma_soc.c fsl_eim.c fsl_eqdc.c fsl_erm.c fsl_freqme.c fsl_glikey.c fsl_gpio.c fsl_i3c.c fsl_i3c_edma.c fsl_inputmux.c fsl_lpadc.c fsl_lpcmp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lptmr.c fsl_lpuart.c fsl_lpuart_edma.c fsl_ostimer.c fsl_pwm.c fsl_reset.c fsl_spc.c fsl_utick.c fsl_vbat.c fsl_waketimer.c fsl_wuu.c fsl_wwdt.c
    packages/nxp-mcx-series-latest/MCXA153/: system_MCXA153.c
  group Utilities
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ulog/: ulog.c
